# Keil uVision project SC92F8463B_BW1_P.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8463B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: SC92F8463B_BW1_P +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: SC92F8463B_ENABLED
  c include: .\Hardware;.\Hardware\HighLevel;.\User;.\Hardware\LowLevel\SinOne\SC92F8463;.\H;.\c;.\Middleware
  group Source Group 1
    ./: STARTUP.A51
  group LowLevel
    ./Hardware/LowLevel/SinOne/SC92F8463/devs/: Ad.c Ad.h Gpio.c Gpio.h PWM.c PWM.h Serial.c Serial.h Timer.c Timer.h Watchdog.c Watchdog.h ExternalInterrupt.c ExternalInterrupt.h
  group HighLevel
    ./Hardware/HighLevel/: Hardware_Config.h AdDrv.c AdDrv.h GpioDrv.c GpioDrv.h PclBuzDrv.c PclBuzDrv.h SerialDrv.c SerialDrv.h SystemDrv.c SystemDrv.h SystemInit.c SystemInit.h TimerDrv.c TimerDrv.h WatchdogDrv.c WatchdogDrv.h ExternalIntDrv.c ExternalIntDrv.h
  group User
    ./User/: product_config.h macrodriver.h user_define.h main.c
    ./H/: SC92F846xB_C.H
  group Middleware
    ./Middleware/Buzzer/: Buzzer.c Buzzer.h
    ./Middleware/WashDish/: WashDish.c WashDish.h
    ./Middleware/LoadDrive/: LoadDrive.c LoadDrive.h
    ./Middleware/ReadSwitch/: ReadSwitch.c ReadSwitch.h
    ./Middleware/Initialization/: Initialization.c Initialization.h
    ./Middleware/Temperatures/: Temperatures.c Temperatures.h
    ./Middleware/TicketHandling/: TicketHandling.c TicketHandling.h
    ./Middleware/IoUart_Simulate/: IoUart_Simulate.c IoUart_Simulate.h
