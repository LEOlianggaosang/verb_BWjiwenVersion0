# Keil uVision project Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC95F8616B SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFFF)  XRAM(0-0x1FFF) CLOCK(32000000)
  output: HC-JS001-CCC-R+R-P +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51
    ./c/: main.c IO_Init.c BTM.c EX_Init.c Timer_Init.c LCD_LED_Init.c Multiplication_Division.c ADC_Init.c Uart_Init.c IAP_Init.c CRC_Init.c CMP_Init.c PWM_Init.c USCI0_Init.c USCI1_Init.c USCIX_Init.c
    ./CRC_Lib/: SC95FXX1XB_CRC_L_lib_V1.0.0.LIB
    ./IAP_Lib/: SC95FXX1XB_IAP_L_lib_V1.4.0.LIB
