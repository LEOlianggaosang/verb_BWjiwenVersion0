# Keil uVision project SC95F8617B_8616B_BW1_R_NEWFORM0.uvproj, settings and files
target SC95F8617B_8616B_BW1_R_NEWFORM0 (MCS-51)
  device: SC95F8616B SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFFF)  XRAM(0-0x1FFF) CLOCK(32000000)
  output: SC95F8617B_8616B_BW1_R_NEWFORM0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: SC95F8616B_ENABLED
  c include: ..\Application;..\Common;..\Hardware;..\Hardware\LowLevel\SinOne\SC95F7617;..\Hardware\HighLevel;..\..\SC95F8617B_8616B_BW1_R _NEWFORM0;..\Main;..\Middleware;..\SC95F8617B_8616B_BW1_R_NEWFORM0;..\SOC_DebugTouchKey_Lib;..\lib
  link misc: REMOVEUNUSED
  group startup
    ./: STARTUP.A51
    ./CRC_Lib/: SC95FXX1XB_CRC_L_lib_V1.0.0.LIB
    ./IAP_Lib/: SC95FXX1XB_IAP_L_lib_V1.4.0.LIB
  group Main
    ../Main/: main.c
    ../Common/: product_config.h user_define.h FuctionSteps_Sheet.h
    ../SOC_DebugTouchKey_Lib/: SC95F8X1XB_HighSensitiveTKDynamicDebug_L_V1.2.0.LIB SOC_DebugTouchKey.h
  group LowLevel
    ../Hardware/LowLevel/SinOne/SC95F7617/devs/: IAP.c IAP.h Serial.c Serial.h macrodriver.h Timer.c Timer.h Watchdog.c Watchdog.h LedRam.c LedRam.h
    ../lib/: S_TouchKeyCFG.C S_TouchKeyCFG.h SC95F8X1XB_HighSensitive_lib_T1_L_V2.1.0.LIB
    ../Hardware/LowLevel/SinOne/SC95F7617/: SC95F861xB_C.H
  group HighLevel
    ../Hardware/HighLevel/: Hardware_Config.h EepromDrv.c EepromDrv.h SerialDrv.c SerialDrv.h SystemDrv.c SystemDrv.h SystemInit.c SystemInit.h TimerDrv.c TimerDrv.h WatchdogDrv.c WatchdogDrv.h TKDrv.C TKDrv.H LedRamDrv.c LedRamDrv.h
    ../lib/: SensorMethod.h
  group Middleware
    ../Middleware/Initialization/: Initialization.c Initialization.h
    ../Middleware/TicketHandling/: TicketHandling.c TicketHandling.h
    ../Middleware/PowerLostMemory/: PowerLostMemory.c PowerLostMemory.h
    ../Middleware/IapAddrDevice/: IapAddrDevice.c IapAddrDevice.h
    ../Middleware/TK/: TK.c TK.h
    ../Middleware/Power/: Power.c Power.h
    ../Middleware/Light/: Light.c Light.h
  group Application
    ../Application/Display/: Display.c Display.h
    ../Application/Key/: Key.c Key.h
    ../Application/Work/: Work.c Work.h
    ../Application/ErrorHandling/: Error.c Error.h
    ../Application/Save/: Save.c Save.h
